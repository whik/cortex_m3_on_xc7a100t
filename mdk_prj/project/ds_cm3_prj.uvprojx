# Keil uVision project ds_cm3_prj.uvprojx, settings and files
target ds_cm3_prj (6150000::V6.15::ARMCLANG)
  device: DS_CM3 ARM
  pack: Keil.V2M-MPS2_DSx_BSP.1.1.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ds_cm3_prj +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../application/: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
